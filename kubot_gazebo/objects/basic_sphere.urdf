Commit message: Sphere rolls more

File: kubot_gazebo/objects/basic_sphere.urdf (robot description, URDF)
Before this commit: robot basic_sphere, 1 links, 0 joints
Links:
- link sphere_link: mass 0.001 -> 0.2
